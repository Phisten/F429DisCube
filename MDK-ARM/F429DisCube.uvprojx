# Keil uVision project F429DisCube.uvprojx, settings and files
target F429DisCube (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F429DisCube +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_HAL_DRIVER,STM32F429xx
  c include: c:\WinDownloads\Project\F429DisCube\MDK-ARM\../Core/Inc; c:\WinDownloads\Project\F429DisCube\MDK-ARM\../Drivers/STM32F4xx_HAL_Driver/Inc; c:\WinDownloads\Project\F429DisCube\MDK-ARM\../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; c:\WinDownloads\Project\F429DisCube\MDK-ARM\../Drivers/CMSIS/Device/ST/STM32F4xx/Include; c:\WinDownloads\Project\F429DisCube\MDK-ARM\../Drivers/CMSIS/Include;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    c:/WinDownloads/Project/F429DisCube/MDK-ARM/../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    c:/WinDownloads/Project/F429DisCube/MDK-ARM/../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    c:/WinDownloads/Project/F429DisCube/MDK-ARM/../Core/Src/: system_stm32f4xx.c
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
